# IAR project project.ewp, settings and files
configuration STM8S105 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 1
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\Libraries\STM8S_StdPeriph_Driver\inc; ..\CS1231; ..\DisplayDriver
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CS1231
    ../CS1231/: ad_filter.c ad_filter.h ad_proc.c ad_proc.h CS1231.c CS1231.h
  group DisplayDriver
    ../DisplayDriver/: ht1621.c ht1621.h TM1668.c TM1668.h
  group Include Files
    ../inc/: CPUled.h factory.h global.h i2c.h key.h key_fun.h normal.h rs232.h timer1.h
  group Source Files
    ../src/: CPUled.c factory.c global.c I2C.c key.c key_fun.c main.c normal.c rs232.c stm8s_it.c timer1.c
  group STM8S_StdPeriph_Lib/inc
    ../../Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_beep.h stm8s_clk.h stm8s_conf.h stm8s_gpio.h stm8s_tim1.h stm8s_tim2.h stm8s_uart2.h
  group STM8S_StdPeriph_Lib/src
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_beep.c stm8s_clk.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_uart2.c
